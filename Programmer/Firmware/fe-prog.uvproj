# Keil uVision project fe-prog.uvproj, settings and files
target Release (MCS-51)
  device: C8051F380 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: fe-prog +hex
  c flags: Optimize=8
  link misc: REMOVEUNUSED
  group Source
    ./: main.c hw.c hw.h bus.c bus.h defs.h psd.c psd.h tests.c tests.h
